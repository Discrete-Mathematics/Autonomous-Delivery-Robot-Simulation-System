Commit message: 优化避障和雷达检测逻辑

File: catkin_ws/src/delivery_system/urdf/delivery_robot.urdf (robot description, URDF)
Before this commit: robot delivery_robot, 4 links, 3 joints
Joints:
- joint laser_joint: origin xyz=0.15 0 0.2 rpy=0 0 0 -> xyz=0.15 0 0.08 rpy=0 0 0
